# Keil uVision project Project.uvprojx, settings and files
target STM32100E-EVAL (ARM-ADS)
  device: STM32F100ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32100E-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD_VL, USE_STM32100E_EVAL
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM32100E_EVAL;..\..\..\Utilities\STM32_EVAL\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ../: stm32f10x_it.c main.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_wwdg.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../: system_stm32f10x.c
  group MDK-ARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s startup_stm32f10x_hd_vl.s
  group Doc
    ./: readme.txt
  group CORE_Source
    ./Source/: delay.c uart.c output.c adc.c timer.c led.c int.c i2c_std.h i2c_std.c
  group OLED
    ./Source/: ssd1306.c ssd1306.h font.h font.c display_screen.h display_screen.c
  group LCD
    ./Source/: lcd.c lcd.h
  group MAX30102
    ./Source/: max30102.c max30102.h spo2.c spo2.h
  group Button
    ./Source/: button.c button.h
target STM3210E-EVAL_XL (ARM-ADS)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210E-EVAL_XL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_XL, USE_STM3210E_EVAL
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL;..\..\..\Utilities\STM32_EVAL\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
target STM32100B-EVAL (ARM-ADS)
  device: STM32F100VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32100B-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD_VL, USE_STM32100B_EVAL
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM32100B_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
target STM3210C-EVAL (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210C-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM3210C_EVAL
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM3210E-EVAL (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210E-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM3210B-EVAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210B-EVAL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL;..\..\..\Utilities\STM32_EVAL\Common;.\Source
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.5.0
